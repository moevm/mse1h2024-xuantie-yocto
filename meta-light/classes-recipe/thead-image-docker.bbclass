inherit thead-image-linux
IMAGE_INSTALL += " docker"
